Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Heidelberg\ECT-HDBG-0600-000 HEIDELBERG.IFC
Time: 2024-11-25T13:14:59+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 13.5243000000000091; Volume Measure: 0.0135243000000000; Area Measure: 2.6582782250993979

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 13.5243000000000091; Volume Measure: 0.0135243000000000; Area Measure: 2.6582782250993979

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 13.5243000000000091; Volume Measure: 0.0135243000000000; Area Measure: 2.6582782250993979

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ECT-HDBG-0600-000 HEIDELBERG | PSet_Mass_Property - Mass Measure: 13.5243000000000091; Volume Measure: 0.0135243000000000; Area Measure: 2.6582782250993979
ECT-HDBG-0600-000 HEIDELBERG
