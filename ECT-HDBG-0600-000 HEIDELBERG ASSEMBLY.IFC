Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Heidelberg\ECT-HDBG-0600-000 HEIDELBERG ASSEMBLY.IFC
Time: 2024-11-25T13:15:42+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 81.1458000000000368; Volume Measure: 0.0811458000000000; Area Measure: 15.9496693505963858

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 81.1458000000000368; Volume Measure: 0.0811458000000000; Area Measure: 15.9496693505963858

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 81.1458000000000368; Volume Measure: 0.0811458000000000; Area Measure: 15.9496693505963858

# IfcBuildingElementProxy (7)
In: default BuildingStorey
Name
ECT-HDBG-0600-000 HEIDELBERG ASSEMBLY.SLDPRT | PSet_Mass_Property - Mass Measure: 81.1458000000000368; Volume Measure: 0.0811458000000000; Area Measure: 15.9496693505963858
ECT-HDBG-0600-000 HEIDELBERG
ECT-HDBG-0600-000 HEIDELBERG-1
ECT-HDBG-0600-000 HEIDELBERG-2
ECT-HDBG-0600-000 HEIDELBERG-3
ECT-HDBG-0600-000 HEIDELBERG-4
ECT-HDBG-0600-000 HEIDELBERG-5
